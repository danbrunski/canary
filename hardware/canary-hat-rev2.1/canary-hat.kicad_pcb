# Repository danbrunski/canary (continued)

## KiCad design hardware/canary-pwr-rev1.0/canary-pwr.kicad_pcb (continued)

Parts:
C36, C38, C41, C42, C43: 100nF 50V X7R; C_0603_1608Metric; MPN CL10B104KB8NNNC
C37, C40: 4.7uF 25V X5R; C_0805_2012Metric; MPN CL21A475KAQNNNE
C39: 1uF 50V X7R; C_0805_2012Metric; MPN CL21B105KBFNNNE
D5, D6: BAT46WS-AQ; D_SOD-323F; MPN BAT46WS-AQ
D7: Green; LED_Kingbright_APA1606_1.6x0.6mm_Horizontal; MPN APA1606SGC
D8: Red; LED_Kingbright_APA1606_1.6x0.6mm_Horizontal; MPN APA1606SURCK
J5: SWD; PinHeader_2x05_P1.27mm_Horizontal; not fitted
R30, R31: 4.7k 1%; R_0603_1608Metric; MPN RC0603FR-074K7L
R32, R33: 1k 1%; R_0603_1608Metric; MPN RC0603FR-071KL
SW1: EVQ-P7A01P; SW_SPST_EVQP7A; MPN EVQ-P7A01P
U5: STM32G031K8T6; LQFP-32_7x7mm_P0.8mm; MPN STM32G031K8T6
U6: TPS7A1633QDGNRQ1; DGN0008C_TPS7A1633AQDGNRQ1_TEX; MPN TPS7A1633QDGNRQ1
U7: TCAN1043HDQ1; SOIC-14_3.9x8.7mm_P1.27mm; MPN TCAN1043HDQ1

Connections:
+3V3_AON: C36.1, C37.1, C40.1, C43.1, J5.1 (VTref), R30.2, R31.2, U5.4 (VDD), U6.1 (OUT), U7.1 (TXD), U7.5 (VIO); also elsewhere on the board
+5V_BUCK: C42.1, U7.3 (VCC); also elsewhere on the board
+12V_BUS: D6.2 (A); also elsewhere on the board
+12V_PROT: C41.1, D5.2 (A), U7.10 (VSUP); also elsewhere on the board
/Supervisor/AON_IN: C39.1, D5.1 (K), D6.1 (K), U6.5 (EN), U6.8 (IN)
/Supervisor/BUTTON: SW1.1, U5.12 (PA5)
/Supervisor/CAN_EN: U5.26 (PA15), U7.6 (EN)
/Supervisor/CAN_FAULT_N: U5.29 (PB5), U7.8 (~FAULT)
/Supervisor/CAN_RXD: U5.28 (PB4), U7.4 (RXD)
/Supervisor/CAN_STB_N: U5.27 (PB3), U7.14 (~STB)
/Supervisor/LED1_A: D7.2 (A), R32.2
/Supervisor/LED2_A: D8.2 (A), R33.2
/Supervisor/LED_BANK: R33.1, U5.14 (PA7)
/Supervisor/LED_STATUS: R32.1, U5.13 (PA6)
/Supervisor/SWDIO: J5.2 (SWDIO/TMS), U5.24 (PA13)
BUCK_PG: U5.2 (PC14); also elsewhere on the board
CANH: U7.13 (CANH); also elsewhere on the board
CANL: U7.12 (CANL); also elsewhere on the board
GND: C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, D7.1 (K), D8.1 (K), J5.3 (GND), J5.5 (GND), J5.9 (GNDDetect), SW1.2, U5.5 (VSS), U6.2 (FB/NC), U6.4 (GND), U6.9 (EP), U7.2 (GND), U7.9 (WAKE); also elsewhere on the board
LTC_PFO: U5.32 (PB8); also elsewhere on the board
LTC_SMBALERT: U5.1 (PB9); also elsewhere on the board
MCU_NRST: C38.1, J5.10 (~RESET), U5.6 (PF2); also elsewhere on the board
MCU_SCL: U5.30 (PB6); also elsewhere on the board
MCU_SDA: U5.31 (PB7); also elsewhere on the board
PI_3V3_SENSE: U5.11 (PA4); also elsewhere on the board
PI_5V_OFF: U5.15 (PB0); also elsewhere on the board
PRIV_SCL: R31.1, U5.22 (PA9/PA11); also elsewhere on the board
PRIV_SDA: R30.1, U5.23 (PA10/PA12); also elsewhere on the board
SWCLK_BOOT0: J5.4 (SWCLK/TCK), U5.25 (PA14); also elsewhere on the board
VIN_SENSE: U5.7 (PA0); also elsewhere on the board
~PWR_FAIL: U5.18 (PA8); also elsewhere on the board

Notes on the sheet:
Always-on 3.3 V
Wake-on-CAN (receive-only by wiring)
Power flags (nets fed by passive pins)
Private I2C pull-ups
STM32G031K8 supervisor
Bench button, status LEDs, SWD
Supervisor: Always-on STM32G031 supervisor, its 3.3 V LDO, wake-on-CAN transceiver, SWD, button, LEDs

Parts:
C45: 100nF 50V X7R; C_0603_1608Metric; MPN CL10B104KB8NNNC
J1: 2x20 stacking hdr 13.5mm (DNP); PinSocket_2x20_P2.54mm_Vertical; not fitted
Q8: BSS138; SOT-23; MPN BSS138
R34, R35, R36, R37, R39, R42: 10k 1%; R_0603_1608Metric; MPN RC0603FR-0710KL
R38, R40: 1k 1%; R_0603_1608Metric; MPN RC0603FR-071KL
R41: 100k 1%; R_0603_1608Metric; MPN RC0603FR-07100KL
U8: TCA9511ADGKR; SOIC8_DGK_TEX; MPN TCA9511ADGKR

Connections:
+5V_PI: J1.2, J1.4; also elsewhere on the board
/Pi_Interface/I2C_READY: R36.1, U8.5 (READY)
/Pi_Interface/NRST_GATE: Q8.1 (G), R40.2, R41.1
/Pi_Interface/PI_3V3: C45.1, J1.1, J1.17, R34.2, R35.2, R36.2, R37.2, R42.1, U8.1 (EN), U8.8 (VCC)
/Pi_Interface/PI_BOOT0: J1.13, R38.1
/Pi_Interface/PI_NRST: J1.18, R40.1
/Pi_Interface/PI_SCL: J1.5, U8.3 (SCLIN)
/Pi_Interface/PI_SDA: J1.3, U8.6 (SDAIN)
GND: C45.2, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, Q8.2 (S), R39.2, R41.2, U8.4 (GND); also elsewhere on the board
MCU_NRST: Q8.3 (D); also elsewhere on the board
MCU_SCL: R35.1, U8.2 (SCLOUT); also elsewhere on the board
MCU_SDA: R34.1, U8.7 (SDAOUT); also elsewhere on the board
PI_3V3_SENSE: R42.2; also elsewhere on the board
SWCLK_BOOT0: R38.2, R39.1; also elsewhere on the board
~PWR_FAIL: J1.31, R37.1; also elsewhere on the board

Notes on the sheet:
Crossing nets (safe-state pulls)
I2C hot-swap buffer (Pi side powered)
Pi 5 header (stacking, the HAT plugs on top)
Power flags (nets fed by passive pins)
Pi Interface: Pi 5 header (stacking), I2C hot-swap buffer, crossing nets into the Pi's 3.3 V domain

Parts:
C22: 1uF 25V X5R; C_0603_1608Metric; MPN CL10A105KA8NNNC
C23, C24, C28, C29, C32, C35: 100nF 50V X7R; C_0603_1608Metric; MPN CL10B104KB8NNNC
C25: 22pF 50V C0G; C_0603_1608Metric; MPN GRM1885C1H220JA01D
C26, C27: 10uF 50V X7R; C_1210_3225Metric; MPN GRM32ER71H106KA12L
C30, C31: 47uF 10V X5R; C_1210_3225Metric; MPN GRM32ER61A476KE20L
C33: 100nF 25V X7R; C_0603_1608Metric; MPN CL10B104KA8NNNC
C34: 22uF 10V X5R; C_1206_3216Metric; MPN GRM31CR61A226KE19L
L2: 4.7uH Isat 14.4A; L_Wuerth_XHMI-6060; MPN 744393465047
Q6: BSS138; SOT-23; MPN BSS138
Q7: NTTFS5C673NLTAG; VSON-8_3.3x3.3mm_P0.65mm_NexFET; MPN NTTFS5C673NLTAG
R21: 33.2k 1%; R_0603_1608Metric; MPN RC0603FR-0733K2L
R22, R25, R27: 100k 1%; R_0603_1608Metric; MPN RC0603FR-07100KL
R23: 24.3k 1%; R_0603_1608Metric; MPN RC0603FR-0724K3L
R24: 1k 1%; R_0603_1608Metric; MPN RC0603FR-071KL
R26: 27k 1%; R_0603_1608Metric; MPN RC0603FR-0727KL
R28: 5mOhm 1% 1W; R_2512_6332Metric; MPN WSL2512R0050FEA
U2: LM61460AASQRJRRQ1; IC_LM61460AFSQRJRRQ1; MPN LM61460AASQRJRRQ1
U3: INA226AIDGSR; TSSOP-10_3x3mm_P0.5mm; MPN INA226AIDGSR
U4: LM74700QDBVTQ1; SOT-23-6; MPN LM74700QDBVTQ1

Connections:
+3V3_AON: C32.1, U3.6 (VS); also elsewhere on the board
+5V_BUCK: C23.1, C25.1, C30.1, C31.1, L2.2, R22.1, R28.1, U2.1 (BIAS), U3.10 (Vin+); also elsewhere on the board
+5V_PI: C34.1, C35.1, Q7.5 (D), U3.8 (Vbus), U4.4 (CATHODE); also elsewhere on the board
+12V_BUS: C26.1, C27.1, C28.1, C29.1, R25.1, U2.8 (VIN1), U2.12 (VIN2); also elsewhere on the board
/Pi_Supply/+5V_SHUNT: C33.2, Q7.1 (S), Q7.2 (S), Q7.3 (S), R28.2, U3.9 (Vin-), U4.3 (EN), U4.6 (ANODE)
/Pi_Supply/BUCK_EN: Q6.3 (D), R25.2, R26.1, U2.7 (EN/SYNC)
/Pi_Supply/LM_CBOOT: C24.1, U2.13 (RBOOT), U2.14 (CBOOT)
/Pi_Supply/LM_FB: R22.2, R23.1, R24.2, U2.4 (FB)
/Pi_Supply/LM_FF: C25.2, R24.1
/Pi_Supply/LM_RT: R21.1, U2.6 (RT)
/Pi_Supply/LM_SW: C24.2, L2.1, U2.10 (SW)
/Pi_Supply/LM_VCC: C22.1, U2.2 (VCC)
/Pi_Supply/OR_GATE: Q7.4 (G), U4.5 (GATE)
/Pi_Supply/OR_VCAP: C33.1, U4.1 (VCAP)
BUCK_PG: U2.5 (PGOOD); also elsewhere on the board
GND: C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.2, C35.2, Q6.2 (S), R21.2, R23.2, R26.2, R27.2, U2.3 (AGND), U2.9 (PGND1), U2.11 (PGND2), U3.1 (A1), U3.2 (A0), U3.7 (GND), U4.2 (GND); also elsewhere on the board
PI_5V_OFF: Q6.1 (G), R27.1; also elsewhere on the board
PRIV_SCL: U3.5 (SCL); also elsewhere on the board
PRIV_SDA: U3.4 (SDA); also elsewhere on the board

Notes on the sheet:
Pi Supply: LM61460 5.1 V buck, input-current monitor, ideal-diode output to the Pi header
Power flags (nets fed by passive pins)
5 V current monitor and ideal-diode output
LM61460 5.1 V buck
Enable (default on) and power-good

Board: 4 copper layers, 65.0 x 56.0 mm, 132 parts (49 on the bottom side), 84 nets.

Other parts of the board:
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial_1mm_Mask2mm
MH1, MH2, MH3, MH4: MountingHole_2.7mm_M2.5

File hardware/canary-pwr-rev1.0/BOM.csv (part):

Designator,Quantity,Value,Footprint,Package,MPN,DNP,Mount_Type,Description,KiLib_Generator,Manufacturer,Note
"C1, C18, C19",3,47uF 50V,CP_Elec_6.3x7.7,6.3x7.7mm SMD can,EEE-FK1H470XP,,smt,"Aluminium electrolytic 47uF 20% 50V 105C, 6.3x7.7mm SMD can",capacitor/SMD/elec_round_polarized,Panasonic,[C1]Bulk on the protected input (HAT C2); [C18]Bulk on VOUT: 100 uF per 2 A of backup current (datasheet)
"C10, C17, C2, C21, C23, C24, C28, C29, C3, C32, C35, C36, C38, C4, C41, C42, C43, C45, C6, C7",20,100nF 50V X7R,C_0603_1608Metric,0603,CL10B104KB8NNNC,,smt,MLCC 100nF 10% 50V X7R 0603,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,[C10]At the DRVCC pin; [C23]BIAS decoupling; [C24]CBOOT; [C28]HF at VIN1; [C29]HF at VIN2; [C38]NRST filter; [C4]VIN decoupling; [C6]Charge-pump flying cap; [C7]VCAPP5 to VCAP
"C11, C13",2,10nF 50V X7R,C_0603_1608Metric,0603,CL10B103KB8NNNC,,smt,MLCC 10nF 10% 50V X7R 0603,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,VC compensation: 8.2-10 nF when backing up through the output ideal diode
C12,1,120pF 50V C0G,C_0603_1608Metric,0603,GRM1885C1H121JA01D,,smt,MLCC 120pF 5% 50V C0G 0603,SMD_2terminal_chip_molded,Murata,Phase lead: RFBO1 x CFBO1 = 1/(2 pi 2 kHz)
C14,1,220nF 25V X7R,C_0603_1608Metric,0603,CL10B224KA8NNNC,,smt,MLCC 220nF 10% 25V X7R 0603,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,CB >= 20 x top-FET Ciss
"C15, C16",2,22uF 25V X5R,C_1206_3216Metric,1206,GRM31CR61E226KE15L,,smt,MLCC 22uF 10% 25V X5R 1206,SMD_2terminal_chip_molded,Murata,
"C20, C26, C27",3,10uF 50V X7R,C_1210_3225Metric,1210,GRM32ER71H106KA12L,,smt,MLCC 10uF 10% 50V X7R 1210,SMD_2terminal_chip_molded,Murata,[C26]CIN at VIN1/PGND1; [C27]CIN at VIN2/PGND2
"C22, C5, C8",3,1uF 25V X5R,C_0603_1608Metric,0603,CL10A105KA8NNNC,,smt,MLCC 1uF 10% 25V X5R 0603,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,VOUTM5 is 5 V below VOUT; cap sees 5 V
C25,1,22pF 50V C0G,C_0603_1608Metric,0603,GRM1885C1H220JA01D,,smt,MLCC 22pF 5% 50V C0G 0603,SMD_2terminal_chip_molded,Murata,CFF 22 pF + RFF 1k (Table 10-2)
"C30, C31",2,47uF 10V X5R,C_1210_3225Metric,1210,GRM32ER61A476KE20L,,smt,MLCC 47uF 10% 10V X5R 1210,SMD_2terminal_chip_molded,Murata,
C33,1,100nF 25V X7R,C_0603_1608Metric,0603,CL10B104KA8NNNC,,smt,MLCC 100nF 10% 25V X7R 0603,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,"Charge-pump cap, VCAP to ANODE"
C34,1,22uF 10V X5R,C_1206_3216Metric,1206,GRM31CR61A226KE19L,,smt,MLCC 22uF 10% 10V X5R 1206,SMD_2terminal_chip_molded,Murata,
"C37, C40, C9",3,4.7uF 25V X5R,C_0805_2012Metric,0805,CL21A475KAQNNNE,,smt,MLCC 4.7uF 10% 25V X5R 0805,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,INTVCC/DRVCC tied; >=2.2 uF
C39,1,1uF 50V X7R,C_0805_2012Metric,0805,CL21B105KBFNNNE,,smt,MLCC 1uF 10% 50V X7R 0805,SMD_2terminal_chip_molded,Samsung Electro-Mechanics,
D1,1,BZT52C15,D_SOD-123,SOD-123,BZT52C15-7-F,,smt,"Zener diode 15V 500mW, SOD-123 (Q_REV gate-source clamp, HAT D3)",,Diodes Inc,
D2,1,SMBJ24A,D_SMB,SMB (DO-214AA),SMBJ24A,,smt,"TVS diode 600W unidirectional, 24V standoff, 38.9V max clamp, SMB (HAT D1)",,Littelfuse,Every 50V capacitor rating on this board follows from this clamp.
D3,1,NUP2105LT1G,SOT-23,SOT-23,NUP2105LT1G,,smt,"Dual-line CAN bus ESD protector, 24V standoff, SOT-23",package/gullwing,onsemi,
D4,1,1N4148W,D_SOD-123,SOD-123,1N4148W-7-F,,smt,"Fast switching diode 75V 150mA, SOD-123 (LTC3350 bootstrap)",,Diodes Inc,"DO NOT SUBSTITUTE a Schottky. Fast PN, not Schottky: the datasheet warns BST-SW pumps past 5.5 V with a Schottky when the step-up runs non-synchronously beside the output ideal diode."
"D5, D6",2,BAT46WS-AQ,D_SOD-323F,SOD-323F,BAT46WS-AQ,,smt,"Schottky diode 100V 150mA, SOD-323F, AEC-Q101",,Diotec Semiconductor,"[D5]DO NOT SUBSTITUTE a lower-voltage Schottky. Diode-OR leg from the input; 100 V because the other leg can sit at 0 V while this one sees the 38.9 V clamp; [D6]DO NOT SUBSTITUTE a lower-voltage Schottky (100 V, as D5). Diode-OR leg from the backed-up bus: keeps the supervisor alive on hold-up after the input is lost"
D7,1,Green,LED_Kingbright_APA1606_1.6x0.6mm_Horizontal,1.6x0.6mm side-view (APA1606),APA1606SGC,,smt,"LED green, side-view 1.6x0.6mm (status, on the board edge)",,Kingbright,
D8,1,Red,LED_Kingbright_APA1606_1.6x0.6mm_Horizontal,1.6x0.6mm side-view (APA1606),APA1606SURCK,,smt,"LED red, side-view 1.6x0.6mm ('bank live': lit only while the button is held or discharge runs)",,Kingbright,
F1,1,PTC 0.5A 40V,Fuse_1812_Bourns_MF-MSMF,1812,MF-MSMF050/40X-2,,smt,"Resettable fuse (PTC) 0.5A hold, 1.0A trip, 40V, 1812",,Bourns,"DO NOT SUBSTITUTE a lower-voltage PTC: 40 V, because the 12 V bus can reach the input clamp's 38.9 V. HAT-out comes off the backed-up bus, so the HAT's K-line transceiver and TMAP supply stay in spec through a crank dip (the LTC3350 holds the bus >= 9 V). Replaces the switched TPS1HB35 (trimmed 2026-10-13). The HAT's own V12_SENSE then reads the bus, not the battery; PWR measures the battery (VIN_SENSE, LTC3350 meas_vin)."
"L1, L2",2,4.7uH Isat 14.4A,L_Wuerth_XHMI-6060,6.6x6.4mm SMD (WE-XHMI 6060),744393465047,,smt,"Shielded power inductor 4.7uH 20%, Isat 14.4A, 6.6x6.4mm (WE-XHMI Performance 6060)",inductor/SMD,Wurth Elektronik,"[L1]L = VIN(max)/(ICHG(max) fSW) = 16/(4 A x 0.75 MHz) = 5.3 uH; Isat must exceed 1.8 x ICHG = 7.2 A; [L2]Isat must reach the LM61460's high-side current limit, 11.5 A max, so a shorted 5 V output does not saturate it (SNVSB70F 10.2.2.3)"
Q1,1,SUD50P06-15,TO-252-2,TO-252 (DPAK),SUD50P06-15-GE3,,smt,"P-channel MOSFET -60V -50A 15mOhm, TO-252 (reverse-polarity block)",package/TO_SOT/SMD,Vishay,"Carried from the HAT (S3.7.1): drain (tab) faces +12V_RAW, source faces +12V_PROT; the body diode conducts input->output."
"Q2, Q3, Q4, Q5, Q7",5,NTTFS5C673NLTAG,VSON-8_3.3x3.3mm_P0.65mm_NexFET,WDFN8 3.3x3.3mm (u8FL),NTTFS5C673NLTAG,,smt,"60V N-channel MOSFET, 13.3mOhm max @4.5V, logic-level, WDFN8 3.3x3.3 (u8FL)",,onsemi,"[Q2]Input ideal diode: source at VIN, drain at VOUTSP. On TI's NexFET SON 3.3x3.3 land; onsemi's own adds only a band soldering the package's two side tabs.; [Q3]Top switch. On TI's NexFET SON 3.3x3.3 land; onsemi's own adds only a band soldering the package's two side tabs.; [Q4]Bottom switch. On TI's NexFET SON 3.3x3.3 land; onsemi's own adds only a band soldering the package's two side tabs.; [Q5]Output ideal diode: source at VCAP, drain at VOUT. On TI's NexFET SON 3.3x3.3 land; onsemi's own adds only a band soldering the package's two side tabs.; [Q7]Ideal-diode FET: source at the buck side, drain at the Pi. On TI's NexFET SON 3.3x3.3 land; onsemi's own adds only a band soldering the package's two side tabs."
"Q6, Q8",2,BSS138,SOT-23,SOT-23,BSS138,,smt,"N-channel MOSFET 50V 220mA, logic-level, SOT-23",package/gullwing,onsemi,"[Q6]MCU high = Pi off. MCU in reset/bootloader/hung -> gate pulled low -> Pi stays powered (spec P7); [Q8]A FET, not a resistor: a powered-off Pi pin would otherwise clamp NRST and hold the supervisor in reset"
"R1, R10, R12, R22, R25, R27, R41, R47, R8",9,100k 1%,R_0603_1608Metric,0603,RC0603FR-07100KL,,smt,"Resistor 100 kOhm 1% 1/10W 0603, thick film",SMD_2terminal_chip_molded,Yageo,[R1]Q_REV gate pull-down (HAT R10); [R22]RFBT 100k; [R25]EN divider: on above ~5.9 V; EN = 2.55 V at 12 V
R11,1,665k 1%,R_0603_1608Metric,0603,RC0603FR-07665KL,,smt,"Resistor 665 kOhm 1% 1/10W 0603, thick film",SMD_2terminal_chip_molded,Yageo,"Power-fail threshold = 1.17 V x (1 + 665/100) = 8.95 V falling. PFO goes to the MCU, not the Pi: a crank dip must not shut the Pi down."
R13,1,10k 0.1%,R_0603_1608Metric,0603,RT0603BRD0710KL,,smt,"Resistor 10 kOhm 0.1% 1/10W 0603, thin film",SMD_2terminal_chip_molded,Yageo,"DO NOT SUBSTITUTE a 1% part. NTC bias, 0.1% low drift (datasheet). Thermistor is on the cap bank."
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