# Repository danbrunski/canary

File README.md (part):

# CANary

> Early anomaly detection and diagnostics for vehicle telemetry via OBD-II and CAN bus monitoring.

CANary is an on-vehicle telemetry, anomaly-detection, and diagnostics platform.
It continuously reads raw CAN bus traffic (SocketCAN — CANary-HAT, Waveshare CAN HAT or
Canable USB) and standardized OBD-II PID reads, uses unsupervised machine
learning to learn normal vehicle behavior and flag anomalous conditions in real
time, and doubles as an **engine performance analysis and diagnostic
workbench** — PID/DID exploration, learned behavior surfaces, physics-derived
channels, trouble codes, and trip/session analysis.

It is designed to be **generalized and adaptable to any OBD-II vehicle**:
per-VIN vehicle profiles partition all learned state, and vehicle-specific
facts live in profile/config/data files rather than code. The current install
is a single 2008 Nissan Xterra, which serves as the development vehicle.

It runs headlessly on a Raspberry Pi 5 mounted in-vehicle, logs all telemetry to local
storage, and surfaces anomaly alerts via a local network dashboard.

The name references both the **CAN** bus and the *"canary in a coal mine"* idiom —
detecting subtle signs of trouble before they become failures.

---

## Features

- **Dual-channel ingestion** — raw CAN frames plus OBD-II Mode 01 / selected
  Mode 22 (Nissan DID) reads through one CAN-native `python-can` path, over
  the CANary-HAT (MCP2518FD/SPI, the current in-vehicle rig; see
  `hardware/canary-hat-rev2.0/`, with rev 2.1 in `hardware/canary-hat-rev2.1/`), the Waveshare 2-CH CAN HAT (MCP2515/SPI) or a
  Canable USB adapter; the ELM327 path remains for emulator/fallback
  coverage. An optional serial NMEA GPS receiver adds ground-speed and
  position channels.
- **Parquet ring buffer** — timestamped, columnar, rotated per ignition session,
  bounded by both age and total bytes, with an emergency low-space sweep.
- **Operating-mode segmentation** — KOEO / warmup / idle / city / highway (with
  a transient-stop sub-mode), so models see context-appropriate signal ranges.
  Behavior models are fit and thresholded per mode.
- **Layered detection** — per-mode Isolation Forest + a GRU-D masking-aware LSTM
  autoencoder (handles canary's multi-rate, gappy telemetry without fabricating
  fills) + first-class behavior residuals, combined in a calibrated-severity
  fusion layer.
- **Sensor committees & physics residuals** — redundant-sensor cross-checks
  (e.g. OBD speed ↔ GPS) and physical-relationship residuals (fuel-trim bank
  balance, MAF/RPM air mass) surface sensor faults and engine misbehavior.
- **Vehicle profiles** — the VIN (Mode 09) keys a per-vehicle data partition:
  training corpus, thresholds, behavior surfaces, and session storage are all
  profile-scoped, so the platform ports to another vehicle without
  cross-contamination.
- **Diagnostics workbench** — learned behavior-surface heatmaps with live
  overlay, a Nissan DID map workbench, custom dashboards and multi-channel
  charting, session replay through the live pipeline (isolated `_replay-*`
  outputs), and an authenticated control plane for captures, retrains, and
  model publishing.
- **Engine tuning & calibration analysis** — named capture profiles (Mode 01,
  Mode 22 and RAM channels at stated rates), ReadMemoryByAddress channels with
  same-instant multi-field windows for quantities that are not DIDs (the ECM's
  commanded target AFR, ROM map-cell traces), delivery-error and fuel-trim
  surface analysis with explicit gates and noise floors, a tune-revision
  registry, and a ROM table viewer. Each RAM address records the calibration
  it was checked on, and a known-answer relation re-verifies it on demand.
- **Local dashboard** — FastAPI + WebSocket, accessible only over the vehicle's LAN.
- **MCP server** — the daemon's read/control surface exposed to MCP-speaking
  agents (Claude Code and others), including ad-hoc SQL over the Parquet
  store.
- **Active diagnostics** — OBD polling, ISO-TP flow control, session control,
  security access, memory reads, and ad-hoc diagnostic/control requests all
  transmit on the bus. The request path accepts any service byte, including
  state-changing and actuation commands. CANary's hard boundary is narrower:
  it writes ECU non-volatile memory (a reflash or calibration write) only with
  the operator's explicit permission for that operation, and never while the
  vehicle is moving or the engine is running. Broadcast CAN capture itself
  remains sniff-only.

See [`docs/CANary-overview.md`](docs/CANary-overview.md) for the full architecture,
requirements, and development phases.

---

## Quick start

### Prerequisites

- Python 3.12+
- For on-vehicle use: Raspberry Pi 5 plus a SocketCAN adapter — CANary-HAT
  (current in-vehicle rig), Waveshare 2-CH CAN HAT or Canable USB. OBD reads run through
  the CAN-native client; no ELM327 is required.

### Install (development)

```bash
python3 scripts/install_deps.py
```

The installer creates `.venv`, installs the development dependencies, detects
the local NVIDIA driver's CUDA capability with `nvidia-smi`, and installs Torch
from the matching PyTorch wheel index. Use `--dry-run` to inspect the selected
commands, or override detection explicitly, for example:

```bash
python3 scripts/install_deps.py --torch cu126
python3 scripts/install_deps.py --torch cpu
```

See [`docs/install.md`](docs/install.md) for the CUDA selection table,
overrides, and verification commands.

### Configure

```bash
cp canary.dev.example.yaml canary.yaml
# edit canary.yaml — vehicle, hardware ports, storage path, model settings
```

`canary.yaml` is gitignored; commit shared development-template changes to
`canary.dev.example.yaml` and deployment-template changes to
`canary.pi.example.yaml` instead.

### Run

```bash
.venv/bin/python -m src.main
```

### Desk mode (no truck)

To edit a ROM and run the simulator on a laptop, with no truck and no CAN
adapter, run one command:

```bash
python3 scripts/canary_desk.py
```

Any Python 3.12+ will do to start it: the script re-launches itself under the
repo's `.venv`, and on a fresh checkout it first creates that venv with
`scripts/install_deps.py` (without Torch; desk mode runs no model). Pass
`--no-bootstrap` to have it refuse instead of installing anything.

It also runs in **companion mode** (`--companion auto`, the default): the
daemon keeps a library under `<state-dir>/library` (`--library-root` to put it
elsewhere), searches the network once at startup for a CANary Pi (an mDNS
browse for `_canary._tcp` where multicast reaches, the conventional names,
the wired `192.168.137.2`, then a sweep of your LAN), and links to the one
it finds. The launcher prints the result on one `companion :`
line; the dashboard's Companion card shows the linked Pi, lets you pick one
when several were found, and syncs sessions or publishes models to it. Your
`CANARY_CONTROL_TOKEN` is handed to the daemon as the *Pi's* token only. The
Pi's own dashboard is still at `http://<pi>:8000`. `--companion off` leaves
all of this out. (The former `scripts/canary_companion.py` is gone; this
is it.)

It starts the whole daemon on a virtual CAN bus with OBD disabled (it never
transmits) and opens the ROM Editor in your browser, already signed in: the
control token travels in the link's `#` fragment, which the browser never
sends to the server. Open ROMs from the GUI: the ROM Library page's upload
today, and an "Open ROM..." button on the ROM Editor is coming. To load a
folder of images up front instead, add `--rom-dir "/path/to/ROM folder"`
(optional; repeatable; also `$CANARY_ROM_DIRS`): it adds the `.OsirisROM` and
plain images to the ROM Library and prints each image's `revision_match`. Only
a `matched` revision can be simulated; any image can be previewed. An
UpRev `.bin` backup is reported and skipped; use the `.OsirisROM`.
That folder is only read.

Everything the daemon writes, the ROM Library included, lives under
`--state-dir` (default `~/canary-data/desk`), never in the checkout. A state
dir inside the checkout is refused. The token is kept at
`<state>/control/desk.token` (mode 0600). The dashboard binds `127.0.0.1` only
(`--host` widens it). On the first run, or after the frontend changes, it
builds the dashboard with `pnpm` (it never installs it). With `--no-browser`
it prints the full link once instead. Ctrl+C stops it. `--help` lists
`--port`, `--replay` and the rest.

### Raspberry Pi / headless

To bring up a fresh Pi for running **and developing** CANary in one idempotent
step (OS packages, dev venv with CPU Torch, `canary.yaml`, built dashboard):

```bash
./scripts/setup_pi_dev.sh        # --help for options
```

For the in-vehicle headless **service**, the flow from a blank SD card is:

1. **Flash Raspberry Pi OS (64-bit)** with Raspberry Pi Imager. In its
   settings, make the user `canary`, turn on SSH, and add your Wi-Fi if the
   Pi should join it.
2. **Get a shell on the Pi**: over Wi-Fi (`ssh canary@<imager-hostname>.local`),
   or with a monitor and keyboard. Before step 3 the Ethernet port is on
   DHCP, so a direct cable only works if the laptop hands out addresses.
3. **Clone and install** (any location works; the installer records where):

   ```bash
   sudo apt install -y git
   git clone <repo-url> ~/canary && cd ~/canary
   sudo scripts/install_pi.sh
   sudo reboot
   ```

   The installer sets up the venv, systemd units, `/etc/canary`, the data
   directory and the dashboard. It also renames the Pi `canary-XXXX` (the last
   four hex digits of its Ethernet MAC) and gives the Ethernet port the fixed
   address **192.168.137.2**, both printed at the end. The reboot applies the
   address and any kernel or overlay changes.
4. **Configure**: `sudo nano /etc/canary/canary.yaml` (vehicle, CAN interface,
   GPS), then `sudo systemctl start canary canary-mcp`.
5. **Open the dashboard** at `http://canary-XXXX.local:8000/`, or
   `http://192.168.137.2:8000/` over a direct cable. For the cable, give the
   laptop's Ethernet adapter `192.168.137.1/24` (Windows Internet Connection
   Sharing does this). A VPN client on the laptop can block local traffic:
   Surfshark's did, so allow LAN access in it or turn it off.
6. **Unlock the controls.** Most panels stay locked until the browser holds
   the control token. On the Pi, run `canary-token`, then paste what it prints
   into the **control token** pill in the dashboard's top bar. Or press **Pair
   this device** in the dashboard and approve it by turning the key
   ACC → ON → ACC, or on the bench with `canary-token pair`.

[`docs/pi-setup.md`](docs/pi-setup.md) covers each step in detail.

After the first install, update and redeploy the complete Pi application with:

```bash
sudo canary-update
```

The command stops before changing anything when a capture is active, then
updates the source, does only the dashboard build / dependency / Pi
configuration work that change needs (`--full` forces all of it), restarts both
services, checks that the daemon comes back, and rolls back to the previous
commit if it does not. It ends with a summary block and an exit code that says
what happened; see `docs/pi-setup.md`.

The daemon serves the browser dashboard, public observation endpoints, and an
authenticated control API on the configured LAN address, defaulting to
`http://<pi-hostname-or-ip>:8000/`. A companion
**MCP server** (Model Context Protocol) runs as a separate systemd unit at
`http://<pi-hostname-or-ip>:8001/mcp` and exposes the same surface — plus
ad-hoc Parquet SQL — to Claude Code, Qwen-Agent, and other MCP-speaking
clients. See [`docs/pi-setup.md`](docs/pi-setup.md),
[`docs/headless-api.md`](docs/headless-api.md), and
[`docs/mcp-server.md`](docs/mcp-server.md).

From a laptop, `scripts/canaryctl.py` drives the authenticated control API:

```bash
export CANARY_HOST=http://192.168.137.2:8000
export CANARY_CONTROL_TOKEN="$(ssh canary@192.168.137.2 canary-token)"
scripts/canaryctl.py preflight
scripts/canaryctl.py capture start --purpose "next drive" --protocol drive
scripts/canaryctl.py tag highway_cruise
scripts/canaryctl.py capture stop
scripts/canaryctl.py jobs start corpus_report
```

### Test / lint / typecheck

**Before every commit run the backend CI-parity gate** — it runs the same
lint, format, type, and pytest commands as CI's Python job, in the same order:

```bash
scripts/check.sh          # ruff check . → ruff format --check . → mypy → pytest -v
scripts/check.sh --fix    # auto-apply `ruff format` + `ruff check --fix`, then gate
scripts/check.sh --fast   # skip pytest (lint/format/type only)
```

Enable the tracked pre-commit hook **once per clone** so this is enforced, not
remembered (the recurring failure is forgetting `ruff format --check .`, which
`ruff check .` does **not** catch):

```bash
git config core.hooksPath scripts/git-hooks   # runs scripts/check.sh --fast pre-commit
```

Bypass for rare WIP commits: `git commit --no-verify`. The raw underlying
commands, if you need them individually:

```bash
.venv/bin/ruff check .
.venv/bin/ruff format --check .
.venv/bin/mypy
.venv/bin/pytest
```

For dashboard changes, also run the frontend checks used by CI:

```bash
cd src/dashboard/static
pnpm install --frozen-lockfile
pnpm typecheck
pnpm test
pnpm e2e
```

Playwright's Chromium browser must be installed once before `pnpm e2e`; see
[`src/dashboard/static/README.md`](src/dashboard/static/README.md) for the
frontend development workflow. During Python iteration, use
`.venv/bin/python -m pytest -m "not integration and not slow"`; reserve bare
pytest for the commit gate.

Do not wrap FastAPI/Starlette `TestClient` tests in GNU `timeout` inside the
Codex sandbox. `timeout 90s .venv/bin/pytest ...` can deadlock AnyIO's blocking
portal and make simple in-process API tests look hung even though
`.venv/bin/pytest ...` completes normally. If a run appears stuck, first rerun
the same pytest command directly before debugging app code.

---

## Project layout

```
canary/
├── canary.dev.example.yaml   # Development template (copy → canary.yaml)
├── canary.pi.example.yaml    # Pi/systemd deployment template
├── pyproject.toml
├── docs/
│   ├── CANary-overview.md    # Architecture, requirements, phases
│   ├── pi-setup.md           # Raspberry Pi 5 bring-up
│   ├── headless-api.md       # REST/WebSocket/browser access
│   ├── implementation-tasks.md
│   └── roadmap/              # Planned work as checklist docs
│       ├── tasks/            #   detailed implementation checklists (D03, W00–W07)
│       └── archive/          #   finished plans, kept for their reasoning
├── systemd/
│   └── canary.service        # Headless daemon unit
├── src/
│   ├── main.py               # Entry point
│   ├── config/               # YAML → Pydantic (one module per section group; src.config re-exports)
│   ├── vehicle/              # Per-VIN profiles, tune revisions, vehicle ledger
│   ├── collection/           # OBD + CAN + GPS ingestion
│   ├── daemon/               # Live capture + inference runtime
│   ├── storage/              # Parquet ring buffer, retention
│   ├── preprocessing/        # Resample, segment, features
│   ├── decode/               # Bindings, DIDs, DTC catalog, behavior models
│   ├── analysis/             # Derived signals, sensor committees, refit
│   ├── models/               # Isolation Forest, GRU-D LSTM AE, TCN
│   ├── alerts/               # Fusion, persistence gating, event logging
│   ├── control/              # Authenticated control API + jobs
│   ├── datasets/             # Dataset export
│   ├── companion/            # Laptop-side library + local API
│   ├── mcp_server/           # MCP surface for agents
│   └── dashboard/            # FastAPI + WebSocket + React frontend
└── tests/
```

---

## Status

The software stack is well past the original collection milestone. The
CAN-native collector and in-vehicle Pi deployment are live, with per-mode
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
## KiCad design hardware/canary-hat-rev2.1/canary-hat.kicad_pcb

File hardware/canary-hat-rev2.1/README.md:

# CANary-HAT rev 2.1 (KiCad project)

Design record: [`docs/CANary-HAT-Rev2.1.md`](../../docs/CANary-HAT-Rev2.1.md),
§13.5.10 for what schematic entry changed against
[`../canary-hat-rev2.0/`](../canary-hat-rev2.0/).

**Status (2026-10-12): layout routed, not yet fabricated.** DRC is clean:
0 violations, 0 unconnected items and 0 schematic parity issues.

[`FAB-NOTES.md`](FAB-NOTES.md) is rev 2.1's own, written from the routed
board. It carries over rev 2.0's stackup, impedance and assembly constraints.
Rev 2.0's other fabrication outputs were deliberately not carried over, so
nothing here can be sent to a fab by mistake: `production/`, `BOM.csv`, the
PCBWay assembly notes and quote, and the DRC/ERC reports. Regenerate them
from this project at fab time; rev 2.0's versions in `../canary-hat-rev2.0/`
are the templates.

J1 is DNP in rev 2.1: the operator fits a 13.5 mm stacking header (open
item 14).

The overlay and bring-up scripts are shared across revisions in
[`../canary-hat-firmware/`](../canary-hat-firmware/).

Parts:
C1: 100n; C_0603_1608Metric; Tolerance 10%; Voltage 50V; MPN CL10B104KB8NNNC
J1: 2x20 stacking hdr 13.5mm (DNP); PinSocket_2x20_P2.54mm_Vertical; not fitted
JP1: ID_WP; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2: 3.9k; R_0603_1608Metric; Tolerance 1%; MPN 0603WAF3901T5E
U1: CAT24C256; SOIC-8_3.9x4.9mm_P1.27mm; MPN CAT24C256WI-GT3

Connections:
+3V3: C1.1, J1.1, J1.17, JP1.2 (B), R1.1, R2.1, U1.8 (VCC); also elsewhere on the board
+5V: J1.2, J1.4; also elsewhere on the board
/GPIO2/SDA1: J1.3; also elsewhere on the board
/GPIO3/SCL1: J1.5; also elsewhere on the board
/GPIO7/SPI0.CE1: J1.26; also elsewhere on the board
/GPIO8/SPI0.CE0: J1.24; also elsewhere on the board
/GPIO9/SPI0.MISO: J1.21; also elsewhere on the board
/GPIO10/SPI0.MOSI: J1.19; also elsewhere on the board
/GPIO11/SPI0.SCLK: J1.23; also elsewhere on the board
/GPIO12/TXD4: J1.32; also elsewhere on the board
/GPIO13/RXD4: J1.33; also elsewhere on the board
/GPIO14/TXD0: J1.8; also elsewhere on the board
/GPIO15/RXD0: J1.10; also elsewhere on the board
/GPIO17: J1.11; also elsewhere on the board
/GPIO19: J1.35; also elsewhere on the board
/GPIO20/PPS: J1.38; also elsewhere on the board
/GPIO21: J1.40; also elsewhere on the board
/GPIO22: J1.15; also elsewhere on the board
/GPIO23: J1.16; also elsewhere on the board
/GPIO25: J1.22; also elsewhere on the board
/GPIO26: J1.37; also elsewhere on the board
/ID_SCL: J1.28, R2.2, U1.6 (SCL)
/ID_SDA: J1.27, R1.2, U1.5 (SDA)
GND: C1.2, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, U1.4 (GND); also elsewhere on the board
unnamed: JP1.1 (A), U1.7 (WP)

Notes on the sheet:
ID_SD and ID_SC PINS: These pins are reserved for HAT ID EEPROM. At boot time this I2C interface will be interrogated to look for an EEPROM that identifes the attached board and allows automagic setup of the GPIOs (and optionally, Linux drivers). Bridging JP1 enables write protection. DO NOT USE th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

Parts:
C11, C12: 100n; C_0603_1608Metric; Tolerance 10%; Voltage 50V; MPN CL10B104KB8NNNC
U6: LSM6DSOX; LGA-14L_STM; MPN LSM6DSOXTR

Connections:
+3V3: C11.1, C12.1, U6.1 (SDO/SA0), U6.5 (VDDIO), U6.8 (VDD), U6.12 (CS); also elsewhere on the board
/GPIO2/SDA1: U6.14 (SDA); also elsewhere on the board
/GPIO3/SCL1: U6.13 (SCL); also elsewhere on the board
/GPIO17: U6.4 (INT1); also elsewhere on the board
/GPIO23: U6.9 (INT2); also elsewhere on the board
GND: C11.2, C12.2, U6.2 (SDX), U6.3 (SCX), U6.6 (GND), U6.7 (GND); also elsewhere on the board

Parts:
C21, C22: 22u/25V; C_1210_3225Metric; Voltage 25V; Tolerance 10%; MPN CL32B226KAJNNNE
C23, C25, C26: 1u/16V; C_0603_1608Metric; Voltage 16V; Tolerance 10%; MPN CL10B105KO8NNNC
C24, C27: 10u/16V; C_0805_2012Metric; Voltage 16V; Tolerance 10%; MPN CL21B106KOQNNNE
C28, C29, C30, C31: 100n; C_0603_1608Metric; Voltage 50V; Tolerance 10%; MPN CL10B104KB8NNNC
C36: 10nF; C_0603_1608Metric; Voltage 50V; Tolerance 5%; MPN GRM1885C1H103JA01D
D7, D8, D9: NUP2105L; SOT-23; MPN NUP2105LT1G
R18: 10k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-0710KL
R19: 18k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-0718KL
R20: 47k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-0747KL
R21, R24: TBD; R_0603_1608Metric; not fitted
R22, R23, R26, R28, R29, R32, R33: 1k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-071KL
R25: 4.99k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-074K99L
R27: 2.7k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-072K7L
R30, R31: 100k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-07100KL
U8: ADS8688AIDBTR; TSSOP-38_4.4x9.7mm_P0.5mm; MPN ADS8688AIDBTR

Connections:
+3V3: C27.1, U8.2 (~RST/PD), U8.34 (DVDD); also elsewhere on the board
+5V: C24.1, C25.1, C26.1, R18.1, U8.9 (AVDD), U8.30 (AVDD); also elsewhere on the board
/5V_SENS: D9.1 (A1), D9.2 (A2), R21.1, R25.1, R28.1; also elsewhere on the board
/Analog_Inputs/5VS_ADC: C30.1, R28.2, U8.23 (AIN_3P)
/Analog_Inputs/AIN0_GND: C36.2, R19.1, U8.17 (AIN_0GND)
/Analog_Inputs/AIN1_GND: C28.2, R23.1, U8.19 (AIN_1GND)
/Analog_Inputs/AIN2_GND: C29.2, R27.1, U8.20 (AIN_2GND)
/Analog_Inputs/AIN3_GND: C30.2, R29.1, U8.22 (AIN_3GND)
/Analog_Inputs/FUEL_N_ADC: C31.2, R33.2, U8.24 (AIN_4GND)
/Analog_Inputs/FUEL_P_ADC: C31.1, R32.2, U8.25 (AIN_4P)
/Analog_Inputs/SENS_R1_ADC: C29.1, R26.2, U8.21 (AIN_2P)
/Analog_Inputs/SENS_V1_ADC: C28.1, R22.2, U8.18 (AIN_1P)
/Analog_Inputs/U8_REFCAP: C22.1, C23.1, U8.7 (REFCAP)
/Analog_Inputs/U8_REFIO: C21.1, U8.5 (REFIO)
/FUEL_GND: D8.2 (A2), R31.1, R33.1; also elsewhere on the board
/FUEL_P: D8.1 (A1), R30.1, R32.1; also elsewhere on the board
/GPIO7/SPI0.CE1: U8.38 (~CS); also elsewhere on the board
/GPIO9/SPI0.MISO: U8.36 (SDO); also elsewhere on the board
/GPIO10/SPI0.MOSI: U8.1 (SDI); also elsewhere on the board
/GPIO11/SPI0.SCLK: U8.37 (SCLK); also elsewhere on the board
/SENS_R1: D7.2 (A2), R24.1, R25.2, R26.1; also elsewhere on the board
/SENS_V1: D7.1 (A1), R20.1, R21.2, R22.1; also elsewhere on the board
/V12_SENSE: C36.1, U8.16 (AIN_0P); also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D7.3 (common), D8.3 (common), D9.3 (common), R18.2, R19.2, R20.2, R23.2, R24.2, R27.2, R29.2, R30.2, R31.2, U8.3 (DAISY), U8.4 (~REFSEL), U8.6 (REFGND), U8.8 (AGND), U8.10 (AUX_IN), U8.11 (AUX_GND), U8.12 (AIN_6P), U8.13 (AIN_6GND), U8.14 (AIN_7P), U8.15 (AIN_7GND), U8.26 (AIN_5GND), U8.27 (AIN_5P), U8.28 (AGND), U8.29 (AGND), U8.31 (AGND), U8.32 (AGND), U8.33 (DGND); also elsewhere on the board

Notes on the sheet:
CH4 FUEL_P: AEM 30-0301 WHITE (analog +) -> AIN_4P, BROWN (analog -) -> AIN_4GND (13.5.3 item 7). FUEL_N_ADC is an INPUT pair leg, never poured to ground.
U8 ADS8688A on SPI0 CE1, SPI mode 1 (CPOL 0, CPHA 1; Linux ti-ads8688). SDO tri-states with CS high, so it shares MISO with U3. ALARM (pin 35) unused. Internal 4.096 V reference: REFSEL low; REFIO/REFCAP start-up 15 ms.
U8 REFERENCE + SUPPLY DECOUPLING (SBAS680 sec. 10-11): all at the pins, no vias on REFCAP.
CH1 SENS_V1: generic VOLTAGE-output sensor port, J2 pin 9. Any driven 0-5 V / 0-3.3 V / 0-10 V output (U8 range set per channel in software). Dev truck: Bosch TMAP pressure.
CH3 5V_SENS sense: ratiometric reference for SENS_V1/SENS_R1. 5V_SENS is a harness wire too (J2 pin 11), so it gets the same series protection.
CH2 SENS_R1: generic RESISTIVE sensor port, J2 pin 10 (pull-up to 5V_SENS). Default suits automotive NTCs (~2-5 kohm at 20 C). Dev truck: Bosch TMAP NTC.
CH0 V12_SENSE: divider R11/R12 + C18 stay on OBD_IO (rev 2.0). Only the AIN_0GND match lives here.
SENSOR HARNESS from J2 pins 9-13 (OBD_IO) + transient clamps (open item 31): 24 V bidirectional, same class as D1. U8's internal OVP is a DC limit, not ESD/EFT immunity.

Parts:
C2: 47u; CP_Radial_D6.3mm_P2.50mm; Tolerance 20%; Voltage 50V; MPN EEU-FR1H470
C18: 10n; C_0603_1608Metric; Voltage 50V; Tolerance 10%; MPN CL10B103KB8NNNC
C19: 1u/50V; C_0805_2012Metric; Voltage 50V; Tolerance 10%; MPN CL21B105KBFNNNE
C20: 4.7u/50V; C_1206_3216Metric; Voltage 50V; Tolerance 10%; MPN CL31B475KBHNNNE
C32: 470pF; C_0603_1608Metric; Voltage 50V; Tolerance 5%; MPN GRM1885C1H471JA01D
D1: SMBJ24A; D_SMB; MPN SMBJ24A
D3: BZT52C15; D_SOD-123; Voltage 15V; MPN BZT52C15
D10: BAT46WJ; D_SOD-323F; MPN BAT46WJ,115
Q1: SUD50P06-15; TO-252-2; Voltage 60V; MPN SUD50P06-15
Q4, Q5: BSS138; SOT-23; MPN BSS138
R10, R11: 100k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD07100KL
R12: 22k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD0722KL
R17, R44, R45: 1M; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-071ML
R46: 470k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-07470KL
R47: 100k; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-07100KL
U9: TPS7A1650QDGNRQ1; Texas_DGN0008B_VSSOP-8-1EP_3x3mm_P0.65mm_EP2x3mm_Mask1.88x1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; MPN TPS7A1650QDGNRQ1

Connections:
+12V: C2.1, C19.1, D1.1 (K), D3.1 (K), D10.1 (K), Q1.3 (S), R11.2, R17.1, R45.1, U9.8 (IN); also elsewhere on the board
/5V_SENS: C20.1, U9.1 (OUT); also elsewhere on the board
/+12V_RAW: Q1.2 (D); also elsewhere on the board
/GPIO19: Q5.1 (G), R47.1; also elsewhere on the board
/Power/U9_EN: C32.1, D10.2 (A), Q4.3 (D), R17.2, R44.1, U9.5 (EN)
/Power/U9_OFF: Q4.1 (G), Q5.3 (D), R45.2, R46.1
/V12_SENSE: C18.1, R11.1, R12.2; also elsewhere on the board
GND: C2.2, C18.2, C19.2, C20.2, C32.2, D1.2 (A), Q4.2 (S), Q5.2 (S), R10.2, R12.1, R44.2, R46.2, R47.2, U9.2 (FB/NC), U9.4 (GND), U9.9 (EP); also elsewhere on the board
unnamed: D3.2 (A), Q1.1 (G), R10.1

Notes on the sheet:
U9 ENABLE (review M1): EN = +12V/2 (R17/R44), so EN <= IN always. Q4 holds EN low by default; GPIO19 high (SENS_PWR_EN) -> Q5 -> Q4 off -> U9 on. Sensor supply is OFF until software enables it; the daemon can switch it off when parked. Standby from +12V ~20 uA.
POWER: OBD 12 V in (J2 pin 1, +12V_RAW) -> Q1 reverse block + D1 transient clamp -> +12V rail (also J2 pin 3, the X1202 feed). 12 V sense divider R11/R12/C18 -> V12_SENSE (ADC CH0). U9 5 V sensor supply -> 5V_SENS (J2 pin 11, sensor ports). Rev 3.0 moves the input chain to CANary-PWR (CANary-HAT-Re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

Parts:
BT1: GNSS backup cell (JST-SH); JST_SH_SM02B-SRSS-TB_1x02-1MP_P1.00mm_Horizontal; MPN SM02B-SRSS-TB
C14: 100n; C_0603_1608Metric; Tolerance 10%; Voltage 50V; MPN CL10B104KB8NNNC
C15: 10u; C_1210_3225Metric; Tolerance 10%; Voltage 25V; MPN CL32B106KAJNNNE
C16: 15p; C_0402_1005Metric; Tolerance 5%; Voltage 50V; MPN CC0402JRNPO9BN150
D2: 1N4148W; D_SOD-123; MPN 1N4148W
J4: U.FL; U.FL_Hirose_U.FL-R-SMT-1_Vertical; MPN U.FL-R-SMT-1(10)
L1: 27n; L_0603_1608Metric; MPN LQG18HN27NJ00D
U7: MAX-M10M-00B; MOD18_MAX-M10M_UBL; MPN MAX-M10M-00B

Connections:
+3V3: C14.1, C15.1, U7.7 (V_IO), U7.8 (VCC); also elsewhere on the board
/GPIO12/TXD4: U7.3 (RXD); also elsewhere on the board
/GPIO13/RXD4: U7.2 (TXD); also elsewhere on the board
/GPIO20/PPS: U7.4 (TIMEPULSE); also elsewhere on the board
GND: BT1.1 (-), C14.2, C15.2, J4.2 (Ext), U7.1 (GND), U7.10 (GND), U7.12 (GND); also elsewhere on the board
unnamed: BT1.2 (+), D2.2 (A)
unnamed: D2.1 (K), U7.6 (V_BCKP)
unnamed: C16.2, J4.1 (In), L1.2
unnamed: C16.1, U7.11 (RF_IN)
unnamed: L1.1, U7.14 (VCC_RF)

Notices in the files:
README.md:
License:
TBD.
