# Repository danbrunski/canary (continued)

## KiCad design hardware/canary-hat-rev2.1/canary-hat.kicad_pcb (continued)

Parts:
C7, C8, C9: 100n; C_0603_1608Metric; Tolerance 10%; Voltage 50V; MPN CL10B104KB8NNNC
C33, C34: 8.2pF; C_0603_1608Metric; Voltage 50V; Tolerance +/-0.25pF; MPN GRM1885C1H8R2CA01D
D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN APT1608SURCK
FL1: 1812CAN-513NRC; L_CommonModeChoke_Coilcraft_1812CAN; MPN 1812CAN-513NRC
R16: 1k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD071KL
R43: 0; R_0603_1608Metric; Tolerance jumper; MPN RC0603JR-070RL
U3: MCP2518FDT-E/SL; SOIC14_SL_MCH; MPN MCP2518FDT-E/SL
U4: TCAN1042VDRQ1; D0008A_L; MPN TCAN1042VDRQ1
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN CX3225SA40000D0PTWCC

Connections:
+3V3: C7.1, C9.1, D6.2 (A), U3.14 (VDD), U4.5 (VIO); also elsewhere on the board
+5V: C8.1, U4.3 (VCC); also elsewhere on the board
/CANFD_Interface/OSC2_DRV: R43.1, U3.5 (OSC2)
/CANFD_Interface/XTAL_IN: C33.1, U3.6 (OSC1), Y1.1
/CANFD_Interface/XTAL_OUT: C34.1, R43.2, Y1.3
/CANH_RAW: FL1.2; also elsewhere on the board
/CANL_RAW: FL1.3; also elsewhere on the board
/GPIO8/SPI0.CE0: U3.13 (nCS); also elsewhere on the board
/GPIO9/SPI0.MISO: U3.12 (SDO); also elsewhere on the board
/GPIO10/SPI0.MOSI: U3.11 (SDI); also elsewhere on the board
/GPIO11/SPI0.SCLK: U3.10 (SCK); also elsewhere on the board
/GPIO22: U4.8 (STB); also elsewhere on the board
/GPIO25: U3.4 (*INT); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C33.2, C34.2, U3.7 (VSS), U4.2 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
unnamed: D6.1 (K), R16.1
unnamed: R16.2, U3.2 (RXCAN), U4.4 (RXD)
unnamed: U3.1 (TXCAN), U4.1 (TXD)
unnamed: FL1.1, U4.7 (CANH)
unnamed: FL1.4, U4.6 (CANL)

Parts:
C3: 100n; C_0603_1608Metric; Tolerance 10%; Voltage 50V; MPN CL10B104KB8NNNC
C4: 220p; C_0603_1608Metric; Tolerance 5%; Voltage 100V; MPN AC0603JRNPO0BN221
D5: 1N4148W; D_SOD-123; MPN 1N4148W
D11: BZT52C15; D_SOD-123; MPN BZT52C15
Q2: BSS84; SOT-23; MPN BSS84
Q3: BSS138; SOT-23; MPN BSS138
R3, R4, R8: 4.7k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD074K7L
R5, R6: 1k; R_0603_1608Metric; Tolerance 1%; MPN ERJ-PA3F1001V
R13, R15: 100k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD07100KL
R14: 10k; R_0603_1608Metric; Tolerance 1%; MPN RT0603FRD0710KL
U2: TLIN1027DRQ1; D0008B_HV; MPN TLIN1027DRQ1

Connections:
+3V3: R3.1, R8.1; also elsewhere on the board
+12V: C3.1, D11.1 (K), Q2.2 (S), R13.1, U2.7 (VSUP); also elsewhere on the board
/GPIO14/TXD0: R6.1, R8.2; also elsewhere on the board
/GPIO15/RXD0: R3.2, U2.1 (RXD); also elsewhere on the board
/GPIO21: Q3.1 (G), R15.1; also elsewhere on the board
/GPIO26: R4.1, U2.2 (EN); also elsewhere on the board
/KLINE: C4.1, D5.1 (K), U2.6 (LIN); also elsewhere on the board
/KLine_Transceiver/KLINE_PU: Q2.3 (D), R5.2
/KLine_Transceiver/Q2_GATE: D11.2 (A), Q2.1 (G), R13.2, R14.1
GND: C3.2, C4.2, Q3.2 (S), R4.2, R15.2, U2.5 (GND); also elsewhere on the board
unnamed: D5.2 (A), R5.1
unnamed: Q3.3 (D), R14.2
unnamed: R6.2, U2.4 (TXD)

Parts:
J2: PT 1,5/13-3,5-H; TerminalBlock_Phoenix_PT-1,5-13-3.5-H_1x13_P3.50mm_Horizont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; MPN 1984727

Connections:
+12V: J2.3; also elsewhere on the board
/5V_SENS: J2.11; also elsewhere on the board
/+12V_RAW: J2.1; also elsewhere on the board
/CANH_RAW: J2.5; also elsewhere on the board
/CANL_RAW: J2.6; also elsewhere on the board
/FUEL_GND: J2.12; also elsewhere on the board
/FUEL_P: J2.13; also elsewhere on the board
/KLINE: J2.7; also elsewhere on the board
/SENS_R1: J2.10; also elsewhere on the board
/SENS_V1: J2.9; also elsewhere on the board
GND: J2.2, J2.4, J2.8; also elsewhere on the board

Notes on the sheet:
J2 rev 2.1: Phoenix PT 1,5/13-3,5-H, one 13-way 3.5 mm block. Rev 2.0's J3 (X1202 feed) folded in; OBD pin 5 (signal ground) dropped. 1 +12V_RAW (OBD 16, 18 AWG) 2 GND chassis (OBD 4, 18 AWG) 3 +12V out to X1202 (18 AWG) 4 GND out to X1202 (18 AWG) 5 CANH (OBD 6) 6 CANL (OBD 14) 7 KLINE (OBD 7) 8 S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

Board: 4 copper layers, 87.0 x 56.0 mm, 104 parts (1 on the bottom side), 68 nets.

Other parts of the board:
FID1, FID2, FID3: Fiducial_1mm_Mask2mm
MH1, MH2, MH3, MH4: MountingHole_2.7mm_M2.5

## KiCad design hardware/canary-pwr-rev1.0/canary-pwr.kicad_pcb

Notes on the sheet:
Stack: NVMe base / Pi 5 / CANary-PWR / CANary HAT (rev 2.1 and later). PWR plugs directly on the Pi; the HAT plugs on PWR's stacking header. Power path: OBD 12 V -> reverse block + TVS -> charger switch (TPS1HB35) -> LTC3350 input ideal diode -> +12V_BUS (backed up by the cap bank) +12V_BUS -> LM61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
CANary-PWR rev 1.0 -- supercapacitor UPS and always-on supervisor for the Pi 5 + CANary HAT

Parts:
C1: 47uF 50V; CP_Elec_6.3x7.7; MPN EEE-FK1H470XP
C2, C3: 100nF 50V X7R; C_0603_1608Metric; MPN CL10B104KB8NNNC
D1: BZT52C15; D_SOD-123; MPN BZT52C15-7-F
D2: SMBJ24A; D_SMB; MPN SMBJ24A
D3: NUP2105LT1G; SOT-23; MPN NUP2105LT1G
F1: PTC 0.5A 40V; Fuse_1812_Bourns_MF-MSMF; MPN MF-MSMF050/40X-2
J2: Vehicle in; PhoenixContact_MC_1,5_4-G-3.81_1x04_P3.81mm_Horizontal; MPN 1803293; not fitted
J3: HAT out; Molex_Micro-Fit_3.0_43045-0600_2x03_P3.00mm_Horizontal; MPN 43045-0600; not fitted
Q1: SUD50P06-15; TO-252-2; MPN SUD50P06-15-GE3
R1: 100k 1%; R_0603_1608Metric; MPN RC0603FR-07100KL
R3: 1M 1%; R_0603_1608Metric; MPN RC0603FR-071ML
R4: 150k 1%; R_0603_1608Metric; MPN RC0603FR-07150KL

Connections:
+12V_BUS: F1.1; also elsewhere on the board
+12V_PROT: C1.1, C2.1, D1.1 (K), D2.1 (K), Q1.3 (S), R3.1; also elsewhere on the board
/Input/+12V_HAT: F1.2, J3.1
/Input/+12V_RAW: J2.1, Q1.2 (D)
/Input/Q_REV_G: D1.2 (A), Q1.1 (G), R1.1
CANH: D3.1 (K), J2.3, J3.3; also elsewhere on the board
CANL: D3.2 (K), J2.4, J3.6; also elsewhere on the board
GND: C1.2, C2.2, C3.2, D2.2 (A), D3.3 (A), J2.2, J3.2, J3.5, R1.2, R4.2; also elsewhere on the board
VIN_SENSE: C3.1, R3.2, R4.1; also elsewhere on the board

Notes on the sheet:
HAT out (pluggable terminal, jumper to the HAT's J2)
Battery sense
Power flags (nets fed by passive pins)
Input: Vehicle input, protection, switched 12 V to the HAT and to the charger
Vehicle input (pluggable terminal)

Parts:
C4, C6, C7, C10, C17, C21: 100nF 50V X7R; C_0603_1608Metric; MPN CL10B104KB8NNNC
C5, C8: 1uF 25V X5R; C_0603_1608Metric; MPN CL10A105KA8NNNC
C9: 4.7uF 25V X5R; C_0805_2012Metric; MPN CL21A475KAQNNNE
C11, C13: 10nF 50V X7R; C_0603_1608Metric; MPN CL10B103KB8NNNC
C12: 120pF 50V C0G; C_0603_1608Metric; MPN GRM1885C1H121JA01D
C14: 220nF 25V X7R; C_0603_1608Metric; MPN CL10B224KA8NNNC
C15, C16: 22uF 25V X5R; C_1206_3216Metric; MPN GRM31CR61E226KE15L
C18, C19: 47uF 50V; CP_Elec_6.3x7.7; MPN EEE-FK1H470XP
C20: 10uF 50V X7R; C_1210_3225Metric; MPN GRM32ER71H106KA12L
D4: 1N4148W; D_SOD-123; MPN 1N4148W-7-F
J4: Cap bank; Molex_Micro-Fit_3.0_43045-1000_2x05_P3.00mm_Horizontal; MPN 43045-1002; not fitted
L1: 4.7uH Isat 14.4A; L_Wuerth_XHMI-6060; MPN 744393465047
Q2, Q3, Q4, Q5: NTTFS5C673NLTAG; VSON-8_3.3x3.3mm_P0.65mm_NexFET; MPN NTTFS5C673NLTAG
R5: 71.5k 1%; R_0603_1608Metric; MPN RC0603FR-0771K5L
R6: 121R 1%; R_0603_1608Metric; MPN RC0603FR-07121RL
R7: 732k 1%; R_0603_1608Metric; MPN RC0603FR-07732KL
R8, R10, R12, R47: 100k 1%; R_0603_1608Metric; MPN RC0603FR-07100KL
R9: 649k 1%; R_0603_1608Metric; MPN RC0603FR-07649KL
R11: 665k 1%; R_0603_1608Metric; MPN RC0603FR-07665KL
R13: 10k 0.1%; R_0603_1608Metric; MPN RT0603BRD0710KL
R14, R15: 8mOhm 1% 1W; R_2512_6332Metric; MPN WSL2512R0080FEA
R16, R17, R18, R19, R20: 2.7R 1% 1W; R_2512_6332Metric; MPN CRCW25122R70FKEG
R43, R44, R45, R46: 100k 1%; R_0402_1005Metric; MPN RC0402FR-07100KL
U1: LTC3350EUHF#PBF; QFN-38_UHF_LIT; MPN LTC3350EUHF#PBF

Connections:
+12V_BUS: C12.1, C18.1, C19.1, C20.1, C21.1, Q3.5 (D), Q5.5 (D), R9.1, R14.2, U1.30 (VOUTSN); also elsewhere on the board
+12V_PROT: C4.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), R11.1, U1.34 (VIN); also elsewhere on the board
/Holdup/BANK_NEG_S: J4.6, R16.2
/Holdup/BANK_POS_S: J4.5, R20.2
/Holdup/BANK_TAP1: J4.9, R17.2
/Holdup/BANK_TAP2: J4.8, R18.2
/Holdup/BANK_TAP3: J4.7, R19.2
/Holdup/LTC_BG: Q4.4 (G), U1.27 (BGATE)
/Holdup/LTC_BST: C14.1, D4.1 (K), U1.26 (BST)
/Holdup/LTC_CAP1: R17.1, R43.2, R44.1, U1.13 (CAP1)
/Holdup/LTC_CAP2: R18.1, R44.2, R45.1, U1.14 (CAP2)
/Holdup/LTC_CAP3: R19.1, R45.2, R46.1, U1.15 (CAP3)
/Holdup/LTC_CAP4: R20.1, R46.2, U1.16 (CAP4)
/Holdup/LTC_CAPFB: R7.2, R8.1, U1.6 (CAPFB)
/Holdup/LTC_CAPRTN: R16.1, R43.1, R47.1, U1.12 (CAPRTN)
/Holdup/LTC_CFN: C6.2, U1.18 (CFN)
/Holdup/LTC_CFP: C6.1, U1.17 (CFP)
/Holdup/LTC_GPI: C13.1, J4.10, R13.2, U1.10 (GPI)
/Holdup/LTC_ICAP: L1.2, R15.1, U1.22 (ICAP)
/Holdup/LTC_INFET: Q2.4 (G), U1.33 (INFET)
/Holdup/LTC_INTVCC: C9.1, C10.1, D4.2 (A), R13.1, U1.28 (DRVCC), U1.29 (INTVCC)
/Holdup/LTC_ITST: R6.1, U1.11 (ITST)
/Holdup/LTC_OUTFB: C12.2, R9.2, R10.1, U1.7 (OUTFB)
/Holdup/LTC_OUTFET: Q5.4 (G), U1.20 (OUTFET)
/Holdup/LTC_PFI: R11.2, R12.1, U1.37 (PFI)
/Holdup/LTC_RT: R5.1, U1.9 (RT)
/Holdup/LTC_SW: C14.2, L1.1, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), U1.24 (SW)
/Holdup/LTC_TG: Q3.4 (G), U1.25 (TGATE)
/Holdup/LTC_VC: C11.1, U1.5 (VC)
/Holdup/LTC_VCAPP5: C7.1, U1.19 (VCAPP5)
/Holdup/LTC_VCC2P5: C8.1, U1.23 (VCC2P5), U1.35 (CAP_SLCT0), U1.36 (CAP_SLCT1)
/Holdup/LTC_VOUTM5: C5.1, U1.32 (VOUTM5)
/Holdup/LTC_VOUTSP: C5.2, Q2.5 (D), R14.1, U1.31 (VOUTSP)
/Holdup/VCAP: C7.2, C15.1, C16.1, C17.1, J4.1, J4.2, Q5.1 (S), Q5.2 (S), Q5.3 (S), R7.1, R15.2, U1.21 (VCAP)
GND: C4.2, C8.2, C9.2, C10.2, C11.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, J4.3, J4.4, Q4.1 (S), Q4.2 (S), Q4.3 (S), R5.2, R6.2, R8.2, R10.2, R12.2, R47.2, U1.8 (SGND), U1.39 (PGND); also elsewhere on the board
LTC_PFO: U1.38 (*PFO); also elsewhere on the board
LTC_SMBALERT: U1.3 (*SMBALERT); also elsewhere on the board
PRIV_SCL: U1.1 (SCL); also elsewhere on the board
PRIV_SDA: U1.2 (SDA); also elsewhere on the board

Notes on the sheet:
LTC3350 backup controller
Cell shunts and the cap-bank connector
Holdup: LTC3350 supercapacitor charger / backup controller and the cap-bank connector
Power flags (nets fed by passive pins)
Power path and bidirectional converter
Tap ladder: holds every CAP pin at 0 V when the bank is unplugged (see R43's Note)
